#include "max_section_content.h"

#include <array>
#include <cctype>
#include <unordered_map>

namespace face {
namespace max_content {

namespace {

inline void px(cv::Mat& c, int x, int y) {
    if (x >= 0 && y >= 0 && x < c.cols && y < c.rows)
        c.at<cv::Vec3b>(y, x) = cv::Vec3b(255, 255, 255);
}

// ── 8×8 symbols (row-major, bit 7 = leftmost column) ─────────────────────────
using Sym = std::array<uint8_t, 8>;
const std::unordered_map<std::string, Sym>& symbols() {
    static const std::unordered_map<std::string, Sym> kS = {
        {"heart",  {0x66,0xFF,0xFF,0xFF,0x7E,0x3C,0x18,0x00}},
        {"star",   {0x18,0x18,0xFF,0x7E,0x3C,0x66,0x42,0x00}},
        {"up",     {0x18,0x3C,0x7E,0xFF,0x3C,0x3C,0x3C,0x00}},
        {"down",   {0x00,0x3C,0x3C,0x3C,0xFF,0x7E,0x3C,0x18}},
        {"left",   {0x10,0x30,0x70,0xFF,0xFF,0x70,0x30,0x10}},
        {"right",  {0x08,0x0C,0x0E,0xFF,0xFF,0x0E,0x0C,0x08}},
        {"check",  {0x00,0x01,0x03,0x86,0xCC,0x78,0x30,0x00}},
        {"cross",  {0x81,0xC3,0x66,0x3C,0x3C,0x66,0xC3,0x81}},
        {"smiley", {0x3C,0x42,0xA5,0x81,0xA5,0x99,0x42,0x3C}},
        {"note",   {0x0C,0x0A,0x0A,0x0A,0x1A,0x3A,0x30,0x00}},
        {"excl",   {0x18,0x18,0x18,0x18,0x18,0x00,0x18,0x00}},
        {"dot",    {0x00,0x00,0x18,0x3C,0x3C,0x18,0x00,0x00}},
    };
    return kS;
}

// ── 5×7 font (column-major, bit r = row r, r=0 top) ──────────────────────────
using Glyph = std::array<uint8_t, 5>;
const std::unordered_map<char, Glyph>& font() {
    static const std::unordered_map<char, Glyph> kF = {
        {' ', {0x00,0x00,0x00,0x00,0x00}},
        {'0', {0x3E,0x51,0x49,0x45,0x3E}}, {'1', {0x00,0x42,0x7F,0x40,0x00}},
        {'2', {0x42,0x61,0x51,0x49,0x46}}, {'3', {0x21,0x41,0x45,0x4B,0x31}},
        {'4', {0x18,0x14,0x12,0x7F,0x10}}, {'5', {0x27,0x45,0x45,0x45,0x39}},
        {'6', {0x3C,0x4A,0x49,0x49,0x30}}, {'7', {0x01,0x71,0x09,0x05,0x03}},
        {'8', {0x36,0x49,0x49,0x49,0x36}}, {'9', {0x06,0x49,0x49,0x29,0x1E}},
        {'A', {0x7E,0x11,0x11,0x11,0x7E}}, {'B', {0x7F,0x49,0x49,0x49,0x36}},
        {'C', {0x3E,0x41,0x41,0x41,0x22}}, {'D', {0x7F,0x41,0x41,0x22,0x1C}},
        {'E', {0x7F,0x49,0x49,0x49,0x41}}, {'F', {0x7F,0x09,0x09,0x09,0x01}},
        {'G', {0x3E,0x41,0x49,0x49,0x7A}}, {'H', {0x7F,0x08,0x08,0x08,0x7F}},
        {'I', {0x00,0x41,0x7F,0x41,0x00}}, {'J', {0x20,0x40,0x41,0x3F,0x01}},
        {'K', {0x7F,0x08,0x14,0x22,0x41}}, {'L', {0x7F,0x40,0x40,0x40,0x40}},
        {'M', {0x7F,0x02,0x0C,0x02,0x7F}}, {'N', {0x7F,0x04,0x08,0x10,0x7F}},
        {'O', {0x3E,0x41,0x41,0x41,0x3E}}, {'P', {0x7F,0x09,0x09,0x09,0x06}},
        {'Q', {0x3E,0x41,0x51,0x21,0x5E}}, {'R', {0x7F,0x09,0x19,0x29,0x46}},
        {'S', {0x46,0x49,0x49,0x49,0x31}}, {'T', {0x01,0x01,0x7F,0x01,0x01}},
        {'U', {0x3F,0x40,0x40,0x40,0x3F}}, {'V', {0x1F,0x20,0x40,0x20,0x1F}},
        {'W', {0x7F,0x20,0x18,0x20,0x7F}}, {'X', {0x63,0x14,0x08,0x14,0x63}},
        {'Y', {0x03,0x04,0x78,0x04,0x03}}, {'Z', {0x61,0x51,0x49,0x45,0x43}},
        {'!', {0x00,0x00,0x5F,0x00,0x00}}, {'?', {0x02,0x01,0x51,0x09,0x06}},
        {'.', {0x00,0x60,0x60,0x00,0x00}}, {':', {0x00,0x36,0x36,0x00,0x00}},
        {'-', {0x08,0x08,0x08,0x08,0x08}}, {'+', {0x08,0x08,0x3E,0x08,0x08}},
        {'/', {0x20,0x10,0x08,0x04,0x02}}, {'=', {0x14,0x14,0x14,0x14,0x14}},
        {'<', {0x08,0x14,0x22,0x41,0x00}}, {'>', {0x00,0x41,0x22,0x14,0x08}},
    };
    return kF;
}

}  // namespace

const std::vector<std::string>& symbol_names() {
    static const std::vector<std::string> n = {
        "heart","star","up","down","left","right",
        "check","cross","smiley","note","excl","dot"};
    return n;
}
const std::vector<std::string>& pattern_names() {
    static const std::vector<std::string> n = {
        "solid","border","checker","bars","blank"};
    return n;
}

void draw_symbol(cv::Mat& canvas, const std::string& name) {
    const auto it = symbols().find(name);
    if (it == symbols().end()) return;
    const Sym& s = it->second;
    // Tile the 8×8 glyph across the whole canvas (each MAX module shows it).
    for (int ty = 0; ty < canvas.rows; ty += 8)
        for (int tx = 0; tx < canvas.cols; tx += 8)
            for (int r = 0; r < 8; ++r)
                for (int c = 0; c < 8; ++c)
                    if (s[r] & (0x80 >> c)) px(canvas, tx + c, ty + r);
}

void draw_pattern(cv::Mat& canvas, const std::string& name, int phase) {
    if (name == "solid") {
        canvas.setTo(cv::Scalar(255, 255, 255));
    } else if (name == "border") {
        for (int x = 0; x < canvas.cols; ++x) { px(canvas, x, 0); px(canvas, x, canvas.rows - 1); }
        for (int y = 0; y < canvas.rows; ++y) { px(canvas, 0, y); px(canvas, canvas.cols - 1, y); }
    } else if (name == "checker") {
        for (int y = 0; y < canvas.rows; ++y)
            for (int x = 0; x < canvas.cols; ++x)
                if (((x >> 1) + (y >> 1)) & 1) px(canvas, x, y);
    } else if (name == "bars") {
        for (int y = 0; y < canvas.rows; ++y)
            for (int x = 0; x < canvas.cols; ++x)
                if (((x + phase) % 4) < 2) px(canvas, x, y);
    }
    // "blank" (and unknown) → leave the canvas clear.
}

int draw_text(cv::Mat& canvas, const std::string& text, int x, int y) {
    for (char ch : text) {
        char up = static_cast<char>(std::toupper(static_cast<unsigned char>(ch)));
        const auto it = font().find(up);
        if (it != font().end()) {
            const Glyph& g = it->second;
            for (int c = 0; c < 5; ++c)
                for (int r = 0; r < 7; ++r)
                    if (g[c] & (1 << r)) px(canvas, x + c, y + r);
        }
        x += 6;   // 5px glyph + 1px gap
    }
    return x;
}

int text_width(const std::string& text) {
    return static_cast<int>(text.size()) * 6;
}

}  // namespace max_content
}  // namespace face
